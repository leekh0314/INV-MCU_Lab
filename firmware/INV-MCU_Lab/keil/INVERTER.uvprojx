# Keil uVision project INVERTER.uvprojx, settings and files
target BAT32G139GH48 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: BAT32G139GK48FA Cmsemicon
  pack: Cmsemicon.BAT32G139.1.0.4
  cpu: IRAM(0x20000000,0x08000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: INV_Ctrl +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\code\head\3_powerlib_h;..\code\head\1_driver_h;..\code\head\2_user_h;..\code\source\2_user_s;..\code\source\3_powerlib_s
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000200 size 0x8000
  group 1_driver_s
    ../code/source/1_driver_s/: adc.c adc_user.c clk.c cmp.c cmp_user.c dac.c div.c dma.c elc.c flash.c flash_user.c gpio.c intp.c intp_user.c key.c key_user.c lin.c pcbz.c pga.c retarget.c rst.c rtc.c rtc_user.c sci.c sci_user.c tim4.c tim4_user.c tima.c tima_user.c timb.c timb_user.c timc.c timc_user.c timm.c timm_user.c wdt.c wdt_user.c
  group 1_driver_h
    ../code/head/1_driver_h/: adc.h clk.h cmp.h dac.h div.h dma.h elc.h flash.h gpio.h intp.h key.h lin.h pcbz.h pga.h rst.h rtc.h sci.h tim4.h tima.h timb.h timc.h timm.h userdefine.h wdt.h
  group 2_user_s
    ../code/source/2_user_s/: main.c interrupt.c sys_variable_init.c sys_define_struct.c sys_hardware_init.c sys_state_machine.c user_parallel.c user_sample.c user_function.c user_stepmotor.c user_sine_table.c user_fault_check.c uart_printf.c
  group 2_user_h
    ../code/head/2_user_h/: sys_mcu_header.h sys_define_parar.h sys_define_struct.h sys_hardware_init.h sys_define_config.h sys_state_machine.h user_parallel.h user_sample.h user_function.h user_stepmotor.h
  group 3_powerlib_s
    ../code/source/3_powerlib_s/: stepmotor_ctrl.c INV_Ctrl.lib
  group 3_powerlib_h
    ../code/head/3_powerlib_h/: LPF.h PID.h PQ_Calc.h InvVol_AM.h Inverter_Ctrl.h Repeat_Ctrl.h stepmotor_ctrl.h Lookup_Table.h PQ_Droop_Ctrl.h INV_Power_Ctrl.h AlgorithmLevel_Headers.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
